# Keil uVision project Project.uvprojx, settings and files
target PY32T020x6_Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: PY32T020x6 Puya
  pack: Puya.PY32T0xx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32T020x6
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\PY32T020\Include;..\..\..\Drivers\PY32T020_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Common
    ./: startup_py32t020xx.s
    ../Src/: system_py32t020.c
  group Application/User
    ../Src/: main.c py32t020_hal_msp.c py32t020_it.c
  group Drivers/PY32T020_HAL_Driver
    ../../../Drivers/PY32T020_HAL_Driver/Src/: py32t020_hal.c py32t020_hal_rcc.c py32t020_hal_rcc_ex.c py32t020_hal_gpio.c py32t020_hal_pwr.c py32t020_hal_cortex.c
  group Doc
    ../: readme.txt
target PY32T020x5_Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: PY32T020x5 Puya
  pack: Puya.PY32T0xx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32T020x5
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x800
target PY32T020Bx6_Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: PY32T020Bx6 Puya
  pack: Puya.PY32T0xx_DFP.1.0.6
  cpu: as above
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32T020Bx6
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
target PY32T020Bx5_Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: PY32T020Bx5 Puya
  pack: Puya.PY32T0xx_DFP.1.0.6
  cpu: as above
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32T020Bx5
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x800
software components: CMSIS:CORE 5.2.0
