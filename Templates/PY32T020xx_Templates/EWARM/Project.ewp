# IAR project Project.ewp, settings and files
configuration PY32T020x6_Project (ARM, debug)
  General.OGChipSelectEditMenu: PY32T020x6 Puya PY32T020x6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32T020x6
  ICCARM.CCIncludePath2: ..\..\..\Drivers\CMSIS\Device\PY32T020\Include; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\PY32T020_HAL_Driver\Inc; ..\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32t020x6_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration PY32T020x5_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32T020x5 Puya PY32T020x5
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32T020x5
  ILINK.IlinkIcfFile: py32t020x5_flash.icf
configuration PY32T020Bx6_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32T020Bx6 Puya PY32T020Bx6
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32T020Bx6
  ILINK.IlinkIcfFile: py32t020bx6_flash.icf
configuration PY32T020Bx5_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32T020Bx5 Puya PY32T020Bx5
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32T020Bx5
  ILINK.IlinkIcfFile: py32t020bx5_flash.icf
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_py32t020.c
  group Drivers/PY32T020_HAL_Driver
    ../../../Drivers/PY32T020_HAL_Driver/Src/: py32t020_hal.c py32t020_hal_cortex.c py32t020_hal_gpio.c py32t020_hal_pwr.c py32t020_hal_rcc.c py32t020_hal_rcc_ex.c
  group Example/EWARM
    ./: startup_py32t020xx.s
  group Example/User
    ../Src/: main.c py32t020_hal_msp.c py32t020_it.c
