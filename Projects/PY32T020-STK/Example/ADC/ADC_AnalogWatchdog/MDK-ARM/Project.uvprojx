# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: PY32T020x6 Puya
  pack: Puya.PY32T0xx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32T020x6
  c include: ..\Inc;..\..\..\..\..\..\Drivers\BSP\PY32T020xx_Start_Kit;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\PY32T020\Include;..\..\..\..\..\..\Drivers\PY32T020_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Common
    ./: startup_py32t020xx.s
    ../Src/: system_py32t020.c
  group Application/User
    ../Src/: main.c py32t020_hal_msp.c py32t020_it.c
  group BSP/py32t020xx_Start_Kit
    ../../../../../../Drivers/BSP/py32t020xx_Start_Kit/: py32t020xx_Start_Kit.c
  group Drivers/PY32T020_HAL_Driver
    ../../../../../../Drivers/PY32T020_HAL_Driver/Src/: py32t020_hal.c py32t020_hal_rcc.c py32t020_hal_rcc_ex.c py32t020_hal_pwr.c py32t020_hal_gpio.c py32t020_hal_cortex.c py32t020_hal_uart.c py32t020_hal_adc.c py32t020_hal_tim.c py32t020_hal_tim_ex.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
