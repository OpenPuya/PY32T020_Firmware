# IAR project Project.ewp, settings and files
configuration Project (ARM, debug)
  General.OGChipSelectEditMenu: PY32T020x6 Puya PY32T020x6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32T020x6
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\PY32T020_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\PY32T020\Include; ..\..\..\..\..\..\Drivers\BSP\PY32T020xx_Start_Kit
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32t020x6_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/PY32T020xx_Start_Kit
    ../../../../../../Drivers/BSP/PY32T020xx_Start_Kit/: py32t020xx_Start_Kit.c
  group Drivers/CMSIS
    ../Src/: system_py32t020.c
  group Drivers/PY32T020_HAL_Driver
    ../../../../../../Drivers/PY32T020_HAL_Driver/Src/: py32t020_hal.c py32t020_hal_rcc.c py32t020_hal_rcc_ex.c py32t020_hal_pwr.c py32t020_hal_gpio.c py32t020_hal_cortex.c py32t020_hal_uart.c py32t020_hal_iwdg.c py32t020_hal_spi.c py32t020_hal_flash.c
  group Example/EWARM
    ./: startup_py32t020xx.s
  group Example/User
    ../Src/: main.c py32t020_hal_msp.c py32t020_it.c
