# Keil uVision project PY32T020xx.uvprojx, settings and files
target PY32T020xx_16 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32T020x6 Puya
  pack: Puya.PY32T0xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32T020xx_16
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY32T020xx_16
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target PY32T020xx_20 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32T020x6 Puya
  pack: Puya.PY32T0xx_DFP.1.0.1
  cpu: as above
  output: PY32T020xx_20
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY32T020xx_20
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY32T020xx_24 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32T020x6 Puya
  pack: Puya.PY32T0xx_DFP.1.0.1
  cpu: as above
  output: PY32T020xx_24
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY32T020xx_24
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY32T020xx_32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32T020x6 Puya
  pack: Puya.PY32T0xx_DFP.1.0.1
  cpu: as above
  output: PY32T020xx_32
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY32T020xx_32
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target FLASH_OB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32T020x6 Puya
  pack: Puya.PY32T0xx_DFP.1.0.1
  cpu: as above
  output: PY32T020xx_OPT
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_OB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target FLASH_OTP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32T020x6 Puya
  pack: Puya.PY32T0xx_DFP.1.0.1
  cpu: as above
  output: PY32T020xx_OTP
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM FLASH_OTP
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
