# Keil uVision project PY32T092xx.uvprojx, settings and files
target PY32T092xx_256 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32T092xC Puya
  pack: Puya.PY32T0xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32T092xx_256
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: PY32T092xC,FLASH_MEM
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target FLASH_OTP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32T092xC Puya
  pack: Puya.PY32T0xx_DFP.1.0.1
  cpu: as above
  output: PY32T092xx_OTP
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: PY32T092xB,FLASH_OTP
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target FLASH_OB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32T092xC Puya
  pack: Puya.PY32T0xx_DFP.1.0.1
  cpu: as above
  output: PY32T092xx_OPT
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: PY32T092xB,FLASH_OB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
